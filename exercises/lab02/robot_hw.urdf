Commit message: lab02.2 - 2D working, urdf working

File: exercises/lab02/robot_hw.urdf (robot description, URDF)
Before this commit: robot my_robot, 5 links, 4 joints
Joints:
- joint prismatic_joint: origin xyz=0 0 0.1 rpy=0 0 0 -> xyz=0 0 0.05 rpy=0 0 0
